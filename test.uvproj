# Keil uVision project test.uvproj, settings and files
target TEST (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: test
  c flags: Optim=1 uC99=1 wLevel=2
  c define: MK60D10
  c include: .\Libraries\devices\inc;.\Libraries\drivers\K\inc;.\Libraries\startup\CoreSupport;.\Libraries\startup\DeviceSupport;.\user\src;.\user\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group startup
    ./Libraries/startup/DeviceSupport/: system_MK60D10.c startup_MK60D10.s
  group drivers
    ./Libraries/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group devices
    ./user/src/: ov7725.c
    ./Libraries/devices/src/: VisualScope.c
  group user
    ./user/src/: main.c System.c ImgProc.c Uarts.c Angle.c CollectData.c Direction.c Display.c Encoder.c Motor.c TrackIdentify.c Velocity.c
  group documents
    ./user/inc/: Param.h PinMap.h Typedef.h
    ./: ReadMe.txt
