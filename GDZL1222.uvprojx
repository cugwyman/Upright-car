# Keil uVision project GDZL1222.uvprojx, settings and files
target Freescale Up-Right Car (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: simple1
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: MK60D10
  c include: .\Libraries\devices\inc;.\Libraries\drivers\K\inc;.\Libraries\startup\CoreSupport;.\Libraries\startup\DeviceSupport;.\user;.\Libraries\devices\inc;.\user\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group startup
    ./Libraries/startup/DeviceSupport/: system_MK60D10.c startup_MK60D10.s
  group drivers
    ./Libraries/drivers/K/src/: adc.c common.c ftm.c gpio.c pit.c systick.c uart.c i2c.c
  group devices
    ./Libraries/devices/src/: VisualScope.c LQ12864.c
  group user
    ./user/src/: main.c System.c CollectData.c Motor.c Encoder.c
    ./User/src/: Angle.c Velocity.c Direction.c ImgProc.c TrackIdentify.c Display.c Uarts.c
  group documents
    ./User/inc/: PinMap.h Param.h TypeDef.h
    ./Documents/: ReadMe.txt
